## drivers/power/supply/Kconfig
```kconfig
#source "drivers/power/supply/qcom/Kconfig"

source "drivers/power/supply/qcom_oem/Kconfig"
```
